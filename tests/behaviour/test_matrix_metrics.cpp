// Was RED (defects MATRIX-DEPTH, MATRIX-TRAILING-GAP, MATRIX-CENTRING,
// MATRIX-EMPTY.
//
// All four live in the Kind::Matrix arm of lib/StaTeX/statex_layout.cpp:155-227.
//
// MATRIX-DEPTH   (:181-182)  H = totalH*0.5 + axis;  D = totalH*0.5 - axis;
//                A matrix shorter than twice the axis height gets D < 0. A box
//                whose bottom edge is above its own baseline is not a thing;
//                the value reaches the caller through RenderStats and feeds
//                any enclosing fraction's D = db.depth - denShift.
//
// MATRIX-TRAILING-GAP (:180, :192)  W accumulates colW[c] + colGap for every
//                column including the last, and each cell box is widened to
//                colW[c] + colGap. The grid therefore carries one full column
//                gap of empty space on its right edge, inside the delimiters.
//
// MATRIX-CENTRING (:192)  Widening a cell box leaves its content at the left
//                of the column. TeX centres cells in their column.
//
// MATRIX-EMPTY   (parser, statex_parser.cpp:428)  `\begin{matrix}\end{matrix}`
//                is accepted as a 0x0 matrix and renders as nothing at all.

#include <unity.h>

#include <cmath>
#include <cstdio>

#include "statex_fontparams.h"
#include "statex_glyphstore.h"
#include "stx_compare.h"
#include "stx_corpus.h"
#include "stx_render.h"
#include "stx_report.h"

using namespace stxtest;
using namespace statex;

void setUp() {}
void tearDown() {}

namespace {

constexpr float kSizePx = 22.0f;

// Resolved exactly as the parser does -- see mathGlyphRecord in stx_render.h
// for why no test decides this for itself any more.
double advanceOf(char ch) {
  const char s[2] = {ch, ''};
  return bareAdvanceSum(s, kSizePx);
}

// Ink centroid of a horizontal band of the image, used to test centring.
bool bandCentroid(const stximg::Image& im, int y0, int y1, double* cx) {
  double mass = 0.0, sx = 0.0;
  for (int y = y0; y < y1 && y < im.h; ++y) {
    for (int x = 0; x < im.w; ++x) {
      const double m = im.at(x, y) / 255.0;
      if (m <= 0.1) continue;
      mass += m;
      sx += m * x;
    }
  }
  if (mass <= 0.0) return false;
  *cx = sx / mass;
  return true;
}

}  // namespace

static void test_matrix_depth_is_never_negative() {
  int bad = 0;
  for (const Case& c : corpusWith(Feature::Matrix)) {
    if (c.expect != Expect::Renders) continue;
    const RenderOutput r = renderStatex(tex32(c.tex));
    if (!r.ok()) continue;
    if (r.stats.depth < 0.0f) {
      std::printf("  '%s' depth=%.2f height=%.2f\n", c.id,
                  static_cast<double>(r.stats.depth),
                  static_cast<double>(r.stats.height));
      bad++;
    }
  }
  TEST_ASSERT_EQUAL_INT(0, bad);
}

static void test_single_row_matrix_is_strutted_not_shrunk() {
  // Corrected against the oracle. An earlier version of this test asserted the
  // matrix depth equalled the cell's depth; MicroTeX says otherwise. For
  // `\begin{matrix}a\end{matrix}` at em=36 it reports height 30, depth 6,
  // where bare 'a' is height 15, depth 0 -- TeX applies an array strut, so
  // every row has a minimum height and depth regardless of content. What is
  // genuinely wrong is a *negative* depth.
  const RenderOutput cell = renderStatex(tex32("a"));
  const RenderOutput mat = renderStatex(tex32("\\begin{matrix}a\\end{matrix}"));
  TEST_ASSERT_TRUE(cell.ok());
  TEST_ASSERT_TRUE(mat.ok());
  std::printf("  'a' h=%.2f d=%.2f ;  1x1 matrix h=%.2f d=%.2f\n",
              static_cast<double>(cell.stats.height),
              static_cast<double>(cell.stats.depth),
              static_cast<double>(mat.stats.height),
              static_cast<double>(mat.stats.depth));
  TEST_ASSERT_TRUE(mat.stats.depth >= 0.0f);
  // Strutted, so the grid is taller than its content, not the same size.
  TEST_ASSERT_TRUE(mat.stats.height > cell.stats.height);
  TEST_ASSERT_TRUE(mat.stats.depth > cell.stats.depth);
}

static void test_no_trailing_column_gap() {
  // A 1x1 matrix is exactly its cell wide. An NxM matrix is the sum of its
  // column widths plus (M-1) gaps -- gaps go *between* columns.
  const double a = advanceOf('a');
  const RenderOutput m11 = renderStatex(tex32("\\begin{matrix}a\\end{matrix}"));
  TEST_ASSERT_TRUE(m11.ok());
  std::printf("  1x1 matrix width %.2f, cell advance %.2f (excess %.2f)\n",
              static_cast<double>(m11.stats.width), a,
              static_cast<double>(m11.stats.width) - a);
  TEST_ASSERT_FLOAT_WITHIN(0.5, a, static_cast<double>(m11.stats.width));
}

static void test_column_gaps_scale_with_column_count() {
  // Two renders differing by one column must differ by exactly one column
  // width plus exactly one gap. With a trailing gap the arithmetic still
  // works, so pin the absolute width instead: 1x2 = a + gap + b.
  const RenderOutput m12 =
      renderStatex(tex32("\\begin{matrix}a&b\\end{matrix}"));
  const RenderOutput m13 =
      renderStatex(tex32("\\begin{matrix}a&b&c\\end{matrix}"));
  TEST_ASSERT_TRUE(m12.ok());
  TEST_ASSERT_TRUE(m13.ok());
  // Read the constant rather than restating it. This test hardcoded 0.60 with
  // a comment saying where it came from, and then said the wrong thing the
  // moment the gap was corrected to TeX's 1 em. What it is actually asserting
  // is the *structure* -- one gap between each pair of columns and none at the
  // ends -- which is independent of the value.
  const double gap = static_cast<double>(fontParams().matrixColGap) * kSizePx;
  const double want12 = advanceOf('a') + advanceOf('b') + gap;
  const double want13 =
      advanceOf('a') + advanceOf('b') + advanceOf('c') + 2 * gap;
  std::printf("  1x2 width %.2f want %.2f ;  1x3 width %.2f want %.2f\n",
              static_cast<double>(m12.stats.width), want12,
              static_cast<double>(m13.stats.width), want13);
  TEST_ASSERT_FLOAT_WITHIN(0.6, want12, static_cast<double>(m12.stats.width));
  TEST_ASSERT_FLOAT_WITHIN(0.6, want13, static_cast<double>(m13.stats.width));
}

static void test_cells_are_centred_in_their_column() {
  // One column, two rows, cells of very different widths. Centred cells put
  // both rows' ink on the same vertical axis; left-aligned cells do not.
  const RenderOutput r =
      renderStatex(tex32("\\begin{matrix}mmm\\\\i\\end{matrix}"));
  TEST_ASSERT_TRUE(r.ok());
  // Reference panel: the same two cells with equal widths, which is what a
  // correctly centred column looks like. The diff shows how far the narrow
  // cell sits from where it should be.
  const RenderOutput even =
      renderStatex(tex32("\begin{matrix}mmm\\mmm\end{matrix}"));
  writeFailureStack(even.image, r.image, "MATRIX-CENTRING",
                    "top: equal-width cells   middle: 'mmm' over 'i'   the "
                    "narrow cell should share the column's centre line",
                    artifactPath("defect_matrix_centring.png"),
                    "reference: equal-width cells",
                    "statex: narrow cell left-aligned");

  const stximg::InkStats st = stximg::inkStats(r.image);
  TEST_ASSERT_TRUE(st.any());
  const int mid = (st.y0 + st.y1) / 2;
  double topCx = 0.0, botCx = 0.0;
  TEST_ASSERT_TRUE(bandCentroid(r.image, st.y0, mid, &topCx));
  TEST_ASSERT_TRUE(bandCentroid(r.image, mid, st.y1 + 1, &botCx));
  std::printf("  wide-row centroid x=%.2f, narrow-row centroid x=%.2f\n", topCx,
              botCx);
  TEST_ASSERT_FLOAT_WITHIN(1.5, topCx, botCx);
}

static void test_empty_environment_refuses() {
  const RenderOutput r = renderStatex(tex32("\\begin{matrix}\\end{matrix}"));
  std::printf("  '\\begin{matrix}\\end{matrix}' -> error=%d width=%.2f\n",
              static_cast<int>(r.error), static_cast<double>(r.stats.width));
  TEST_ASSERT_FALSE(r.ok());

  const RenderOutput b = renderStatex(tex32("\\begin{bmatrix}\\end{bmatrix}"));
  TEST_ASSERT_FALSE(b.ok());
}

static void test_delimiters_hug_the_grid() {
  // A bracketed matrix is the plain grid plus exactly two delimiter widths.
  const RenderOutput plain =
      renderStatex(tex32("\\begin{matrix}a&b\\\\c&d\\end{matrix}"));
  const RenderOutput brack =
      renderStatex(tex32("\\begin{bmatrix}a&b\\\\c&d\\end{bmatrix}"));
  TEST_ASSERT_TRUE(plain.ok());
  TEST_ASSERT_TRUE(brack.ok());
  const double delta = static_cast<double>(brack.stats.width) -
                       static_cast<double>(plain.stats.width);
  std::printf("  bracket overhead %.2f px for two delimiters\n", delta);
  TEST_ASSERT_TRUE(delta > 0.0);
  // Two delimiters at this size are nowhere near a whole extra column.
  TEST_ASSERT_TRUE(delta < 2.0 * 0.60 * kSizePx);
}

static void test_matrix_row_order_is_top_to_bottom() {
  // Not defective; guards the row cursor arithmetic (:198-199) against a
  // regression while the surrounding metrics are being fixed.
  const RenderOutput r =
      renderStatex(tex32("\\begin{matrix}m\\\\i\\end{matrix}"));
  TEST_ASSERT_TRUE(r.ok());
  const stximg::InkStats st = stximg::inkStats(r.image);
  TEST_ASSERT_TRUE(st.any());
  const int mid = (st.y0 + st.y1) / 2;
  long topInk = 0, botInk = 0;
  for (int y = st.y0; y <= st.y1; ++y) {
    for (int x = 0; x < r.image.w; ++x) {
      if (r.image.at(x, y) < 32) continue;
      if (y < mid) topInk++; else botInk++;
    }
  }
  // 'm' is much heavier than 'i', and it is the first row.
  std::printf("  top-band ink %ld, bottom-band ink %ld\n", topInk, botInk);
  TEST_ASSERT_TRUE(topInk > botInk);
}

int main(int, char**) {
  UNITY_BEGIN();
  RUN_TEST(test_matrix_depth_is_never_negative);
  RUN_TEST(test_single_row_matrix_is_strutted_not_shrunk);
  RUN_TEST(test_no_trailing_column_gap);
  RUN_TEST(test_column_gaps_scale_with_column_count);
  RUN_TEST(test_cells_are_centred_in_their_column);
  RUN_TEST(test_empty_environment_refuses);
  RUN_TEST(test_delimiters_hug_the_grid);
  RUN_TEST(test_matrix_row_order_is_top_to_bottom);
  return UNITY_END();
}
